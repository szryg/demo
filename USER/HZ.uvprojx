# Keil uVision project HZ.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HZ +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\SD;..\MALLOC;..\USMART;..\HARDWARE\FLASH;..\FATFS\src;..\FATFS\exfuns;..\TEXT;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\TOUCH;..\HARDWARE;..\Gizwits;..\Utils;..\EasyGUI;..\Window;..\EXOUT;..\PathHeadler;..\HARDWARE\ADC;..\HARDWARE\NTC_Temp;..\TaskMan
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ott2001a.c touch.c gt9147.c ft5206.c
    ../HARDWARE/: gather.c Timer.c uart4.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/NTC_Temp/: NTC_Temp.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group Utils
    ../Utils/: ringbuffer.c dataPointTools.c common.c
  group Gizwits
    ../Gizwits/: gizwits_protocol.c gizwits_product.c
  group EasyGUI
    ../EasyGUI/: EasyGUI.c GUI_User.c message.c
  group Window
    ../Window/: Activity_main.c Activity1.c Activity2.c Activity3.c Activity4.c general.c window.h Poweron.c
  group EXOUT
    ../EXOUT/: EXOUT.c EXOUT.h
  group PathHeadler
    ../PathHeadler/: Temp_Control.c Cavity.c Wind.c Wind&Light.c Light.c Fruit.c Norm.c NormX2.c NormX3.c Auto.c
  group TaskMan
    ../TaskMan/: TaskMan.c TaskMan.h
  group README
    ../: README.TXT
